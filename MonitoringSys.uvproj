# Keil uVision project MonitoringSys.uvproj, settings and files
target Monitoring System (ARM-ADS)
  device: LPC2378 NXP (founded by Philips)
  cpu: IRAM(0x40000000-0x40007FFF) IRAM2(0x7FE00000-0x7FE037FF) IROM(0-0x7FFFF) CLOCK(12000000) CPUTYPE(ARM7TDMI)
  output: SD_File
  c flags: Optim=4 v6Lang=1 v6LangP=1
  c include: ..\Library
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x40000000 size 0x8000
  memory RVCT10: RAM 0x7fd00000 size 0x2000
  group Source Files
    ./: Main.c Getline.c initialization.c
  group Configuration Files
    ./: LPC2300.s File_Config.c MCI_LPC23xx.c
  group Com Port
    ./: Retarget.c Serial.c
  group RT Agent
    ./: RTA_LPC2300.s RTA_Config.c
  group Library
    C:/Program Files/Keil/ARM/RV31/LIB/: FS_ARM_L.lib
  group CAN
    ./: CAN.c
  group GLCD
    ./: KS0108.c KS0108-LPC.c
  group Touch
    ./: tc_ad7843_v1_00.c
  group SPI
    ./: spi_lpc23xx_v1_01.c
target Monitoring System RT_Agent (ARM-ADS)
  device: LPC2378 NXP (founded by Philips)
  cpu: as above
  output: SD_File
  c flags: Optim=4 v6Lang=1 v6LangP=1
  c define: RT_AGENT
  c include: ..\Library
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x40000000 size 0x8000
  memory RVCT10: RAM 0x7fd00000 size 0x2000
