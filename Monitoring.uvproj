# Keil uVision project Monitoring.uvproj, settings and files
target Monitornig (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: LPC2368 NXP (founded by Philips)
  cpu: IRAM(0x40000000-0x40007FFF) IRAM2(0x7FE00000-0x7FE03FFF) IROM(0-0x7FFFF) CLOCK(12000000) CPUTYPE(ARM7TDMI)
  output: Monitoring +hex
  c flags: Optim=1 v6Lang=1 v6LangP=1
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x40000000 size 0x8000
  memory RVCT10: RAM 0x7fe00000 size 0x4000
  group StartUP
    ./: LPC2300.s
  group SourceCode
    ./: Main.c Tab.c
  group Driver
    ./: CAN.c initialization.c KS0108.c KS0108-LPC.c spi_lpc23xx_v1_01.c tc_ad7843_v1_00.c Delay.c graphic.c
